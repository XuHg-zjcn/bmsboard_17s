# Repository XuHg-zjcn/bmsboard_17s

File README.md:

# 17串锂电池保护板
使用[PB7170](http://www.pengshenchip.com/ProductsStd_253.html)作为AFE

## 目标特征
### 通信交互接口
- CAN通信
- 电子墨水(显示电量等信息)
- RGB LED
- 蜂鸣器
- 蓝牙通信(不得使用专有固件)
- LoRa通信

### 传感器
- 每节电池电压
- 电流
- 电芯温度(NTC + 二极管组成温度传感器2D阵列)
- 内部空气 温度,湿度,气压
- 加速度计
- 应变计(安装在外壳内壁和电芯表面，使用ADS1243作为ADC)
- 水浸传感器（电极式，用于外壳内壁）

### 保护
- 过压欠压
- 过流保护
- 短路保护
- 过冷过热保护

除短路和严重过流保护外，不应直接切断，必须先通信确认，使负载处于安全状态（如数据已经保存，电动车停在安全区域），或超时后直接切断

### 其他特征
- 数据记录
- 防盗
- 异常提示
- 休眠模式

## 架构
主MCU(直接与AFE连接)与通信MCU分离

## 版权和许可证
Copyright (C) 2025-2026 徐瑞骏
本设计使用的为许可证“CERN Open Hardware Licence Version 2 - Strongly Reciprocal”

## KiCad design bmsboard_17s.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 100n; C_0603_1608Metric
C6, C10: C; C_0603_1608Metric
C7: 1uF; C_0603_1608Metric
C8, C9, C28, C29: 1u; C_0402_1005Metric
C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27: 1u; C_0603_1608Metric
D1, D3: 15V; D_SOD-323
D2: D_TVS; D_SOD-323
D4, D8, D28, D29: D; D_SOD-323
D5, D6: 90V; D_SOD-323
D7: 3.6V; D_SOD-323
D9, D30: D_Zener; D_SOD-323
D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27: 6.5V; D_SOD-323
J1: Conn_01x18
Q1, Q2, Q29, Q30, Q31, Q32, Q33, Q34, Q35, Q36, Q37, Q38: Q_NMOS_GDS; TO-252-2
Q3: Q_PMOS_GDS; SOT-23
Q4: Q_NPN_BEC; SOT-23
Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26: Q_NMOS_GDS; SOT-23
R1: 0.005; R_2512_6332Metric
R2, R3, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R51, R52, R53, R54, R55, R57: 100; R_0402_1005Metric
R4, R56: 100; R_0603_1608Metric
R5, R8, R59, R60: 1M; R_0603_1608Metric
R6: 10k; R_0603_1608Metric
R7, R48: 1k; R_0402_1005Metric
R9: 10; R_0603_1608Metric
R27, R50, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98: 1k; R_0603_1608Metric
R28, R58: R; R_0402_1005Metric
R29, R30: 0; R_0603_1608Metric
R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47: 33; R_1206_3216Metric
R49: 100k; R_0603_1608Metric
U1: PB7170; LQFP-64_10x10mm_P0.5mm

Connections:
+3.3V: C6.1, D7.1 (K), Q4.2 (E), R49.2, R58.1; also elsewhere on the board
/AFE Module/ALERT: R57.1
/AFE Module/BAT0: C10.1, C11.2, D11.2 (A), D28.2 (A), D29.1 (K), J1.18, Q10.3 (S), R28.1, U1.36 (C0)
/AFE Module/BAT1: C11.1, C12.2, D10.1 (K), D11.1 (K), D12.2 (A), J1.17, Q11.3 (S), R31.2, U1.34 (C1)
/AFE Module/BAT2: C12.1, C13.2, D12.1 (K), D13.2 (A), J1.16, Q12.3 (S), R32.2, U1.32 (C2)
/AFE Module/BAT3: C13.1, C14.2, D13.1 (K), D14.2 (A), J1.15, Q13.3 (S), R33.2, U1.30 (C3)
/AFE Module/BAT4: C14.1, C15.2, D14.1 (K), D15.2 (A), J1.14, Q14.3 (S), R34.2, U1.28 (C4)
/AFE Module/BAT5: C15.1, C16.2, D15.1 (K), D16.2 (A), J1.13, Q15.3 (S), R35.2, U1.26 (C5)
/AFE Module/BAT6: C16.1, C17.2, D16.1 (K), D17.2 (A), J1.12, Q16.3 (S), R36.2, U1.24 (C6)
/AFE Module/BAT7: C17.1, C18.2, D17.1 (K), D18.2 (A), J1.11, Q17.3 (S), R37.2, U1.22 (C7)
/AFE Module/BAT8: C18.1, C19.2, D18.1 (K), D19.2 (A), J1.10, Q18.3 (S), R38.2, U1.20 (C8)
/AFE Module/BAT9: C19.1, C20.2, D19.1 (K), D20.2 (A), J1.9, Q19.3 (S), R39.2, U1.18 (C9)
/AFE Module/BAT10: C20.1, C21.2, D20.1 (K), D21.2 (A), J1.8, Q20.3 (S), R40.2, U1.16 (C10)
/AFE Module/BAT11: C21.1, C22.2, D21.1 (K), D22.2 (A), J1.7, Q21.3 (S), R41.2, U1.14 (C11)
/AFE Module/BAT12: C22.1, C23.2, D22.1 (K), D23.2 (A), J1.6, Q22.3 (S), R42.2, U1.12 (C12)
/AFE Module/BAT13: C23.1, C24.2, D23.1 (K), D24.2 (A), J1.5, Q23.3 (S), R43.2, U1.10 (C13)
/AFE Module/BAT14: C24.1, C25.2, D24.1 (K), D25.2 (A), J1.4, Q24.3 (S), R44.2, U1.8 (C14)
/AFE Module/BAT15: C25.1, C26.2, D25.1 (K), D26.2 (A), J1.3, Q25.3 (S), R45.2, U1.6 (C15)
/AFE Module/BAT16: C26.1, C27.2, D26.1 (K), D27.2 (A), J1.2, Q26.3 (S), R46.2, U1.4 (C16)
/AFE Module/BAT17: C27.1, D9.1 (K), D27.1 (K), J1.1, R47.2, U1.2 (C17)
/AFE Module/BAT-: R1.1, R2.2
/AFE Module/CHG: D3.1 (K), Q3.3 (S), U1.42 (CHG)
/AFE Module/CHGD: R60.1, U1.44 (CHGD)
/AFE Module/DRIVE: R48.1, U1.53 (DRIVE)
/AFE Module/DSG: R4.1, U1.40 (DSG)
/AFE Module/GPIO1: R51.1
/AFE Module/GPIO2: R53.1
/AFE Module/LODD: R59.2, U1.43 (LODD)
/AFE Module/MOSG_CHG: D2.2 (A2), R6.2, R7.1, R8.1, R27.1, R88.1, R89.1, R90.1, R91.1, R92.1
/AFE Module/MOSG_DSG: D1.1 (K), R4.2, R5.1, R93.2, R94.2, R95.2, R96.2, R97.2, R98.2
/AFE Module/PACK-: C5.2, D2.1 (A1), D6.2 (A), Q2.3 (S), Q29.3 (S), Q31.3 (S), Q33.3 (S), Q35.3 (S), Q37.3 (S), R8.2, R60.2
/AFE Module/S1: R10.2, U1.35 (S1)
/AFE Module/S2: R11.2, U1.33 (S2)
/AFE Module/S3: R12.2, U1.31 (S3)
/AFE Module/S4: R13.2, U1.29 (S4)
/AFE Module/S5: R14.2, U1.27 (S5)
/AFE Module/S6: R15.2, U1.25 (S6)
/AFE Module/S7: R16.2, U1.23 (S7)
/AFE Module/S8: R17.2, U1.21 (S8)
/AFE Module/S9: R18.2, U1.19 (S9)
/AFE Module/S10: R19.2, U1.17 (S10)
/AFE Module/S11: R20.2, U1.15 (S11)
/AFE Module/S12: R21.2, U1.13 (S12)
/AFE Module/S13: R22.2, U1.11 (S13)
/AFE Module/S14: R23.2, U1.9 (S14)
/AFE Module/S15: R24.2, U1.7 (S15)
/AFE Module/S16: R25.2, U1.5 (S16)
/AFE Module/S17: R26.2, U1.3 (S17)
/AFE Module/SRN: C1.2, C3.2, R3.1, U1.39 (SRN)
/AFE Module/SRP: C1.1, C2.2, R2.1, U1.38 (SRP)
/AFE Module/SW_INNER: C4.1, D1.2 (A), D5.2 (A), Q1.3 (S), Q30.3 (S), Q32.3 (S), Q34.3 (S), Q36.3 (S), Q38.3 (S), R1.2, R3.2, R5.2, R29.1
/AFE Module/SW_MID: C4.2, C5.1, D5.1 (K), D6.1 (K), Q1.2 (D), Q2.2 (D), Q29.2 (D), Q30.2 (D), Q31.2 (D), Q32.2 (D), Q33.2 (D), Q34.2 (D), Q35.2 (D), Q36.2 (D), Q37.2 (D), Q38.2 (D), R59.1
/CS_AFE: R55.1; also elsewhere on the board
/MISO: R52.1; also elsewhere on the board
/MOSI: R54.1; also elsewhere on the board
/SCLK: R56.1; also elsewhere on the board
BAT+: D8.2 (A), D9.2 (A), R50.1; also elsewhere on the board
GND: C2.1, C3.1, C6.2, C7.2, C10.2, C29.1, D3.2 (A), D7.2 (A), D10.2 (A), D28.1 (K), D29.2 (A), D30.2 (A), Q3.1 (G), R28.2, R29.2, R30.1, U1.37 (PGND), U1.64 (DGND); also elsewhere on the board
GNDA: C8.1, C9.1, C28.1, R30.2, U1.45 (AGND)
unnamed: D4.2 (A), Q3.2 (D), R6.1
unnamed: D4.1 (K), R7.2
unnamed: D8.1 (K), R9.1
unnamed: C7.1, D30.1 (K), R9.2, U1.1 (PVDD)
unnamed: Q1.1 (G), R93.1
unnamed: Q2.1 (G), R27.2
unnamed: Q4.1 (B), R48.2, R49.1
unnamed: Q4.3 (C), R50.2
unnamed: Q10.2 (D), R31.1
unnamed: Q10.1 (G), R10.1
unnamed: Q11.2 (D), R32.1
unnamed: Q11.1 (G), R11.1
unnamed: Q12.2 (D), R33.1
unnamed: Q12.1 (G), R12.1
unnamed: Q13.2 (D), R34.1
unnamed: Q13.1 (G), R13.1
unnamed: Q14.2 (D), R35.1
unnamed: Q14.1 (G), R14.1
unnamed: Q15.2 (D), R36.1
unnamed: Q15.1 (G), R15.1
unnamed: Q16.2 (D), R37.1
unnamed: Q16.1 (G), R16.1
unnamed: Q17.2 (D), R38.1
unnamed: Q17.1 (G), R17.1
unnamed: Q18.2 (D), R39.1
unnamed: Q18.1 (G), R18.1
unnamed: Q19.2 (D), R40.1
unnamed: Q19.1 (G), R19.1
unnamed: Q20.2 (D), R41.1
unnamed: Q20.1 (G), R20.1
unnamed: Q21.2 (D), R42.1
unnamed: Q21.1 (G), R21.1
unnamed: Q22.2 (D), R43.1
unnamed: Q22.1 (G), R22.1
unnamed: Q23.2 (D), R44.1
unnamed: Q23.1 (G), R23.1
unnamed: Q24.2 (D), R45.1
unnamed: Q24.1 (G), R24.1
unnamed: Q25.2 (D), R46.1
unnamed: Q25.1 (G), R25.1
unnamed: Q26.2 (D), R47.1
unnamed: Q26.1 (G), R26.1
unnamed: Q29.1 (G), R88.2
unnamed: Q30.1 (G), R94.1
unnamed: Q31.1 (G), R89.2
unnamed: Q32.1 (G), R95.1
unnamed: Q33.1 (G), R90.2
unnamed: Q34.1 (G), R96.1
unnamed: Q35.1 (G), R91.2
unnamed: Q36.1 (G), R97.1
unnamed: Q37.1 (G), R92.2
unnamed: Q38.1 (G), R98.1
unnamed: R57.2, R58.2, U1.56 (ALERT)
unnamed: C8.2, U1.47 (AVDD)
unnamed: R55.2, U1.62 (CSN)
unnamed: C29.2, U1.55 (DVDD)
unnamed: R51.2, U1.58 (GPIO1)
unnamed: R53.2, U1.59 (GPIO2)
unnamed: R56.2, U1.63 (SCLK)
unnamed: R54.2, U1.61 (SDI)
unnamed: R52.2, U1.60 (SDO)
unnamed: C28.2, U1.48 (VAA)
unnamed: C9.2, U1.46 (VREF)

Parts:
C36, C40: 1uF; C_0402_1005Metric
C41: 10nF; C_0402_1005Metric
C45, C52, C53, C54: 0.1uF; C_0402_1005Metric
J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
Q27, Q28: PMOS; SOT-23
R72: 100k; R_0402_1005Metric
R73, R74: 4.7k; R_0402_1005Metric
R75, R76, R80, R83: 1k; R_0402_1005Metric
R77, R78, R79, R81, R82: R; R_0402_1005Metric
U4: 74HC138; SSOP-16_4.4x5.2mm_P0.65mm
U5: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U6: ${SIM.PARAMS}
U7: Si7020-A20; DFN-6-1EP_3x3mm_P1mm_EP1.5x2.4mm
U8: QMA6100P; LGA-12_2x2mm_P0.5mm
U9: ADS1243; TSSOP-20_4.4x6.5mm_P0.65mm
U12: PY32F003F1xUx; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm

Connections:
+3.3V: C45.2, C52.2, C53.2, C54.2, Q27.3 (S), Q28.3 (S), R72.2, R77.2, U4.6 (E2), U4.16 (VCC), U5.6 (VDDIO), U5.8 (VDD), U6.3 (V+), U7.5 (VDD), U8.3 (VDDIO), U8.7 (VDD), U8.10 (~CS), U9.1 (VDD), U12.6 (VCC); also elsewhere on the board
/CS_AD: U9.16 (~CS); also elsewhere on the board
/MISO: U9.18 (DOUT), U12.7 (PA13_SWD); also elsewhere on the board
/MOSI: U9.17 (DIN), U12.9 (PB5); also elsewhere on the board
/SCLK: U9.19 (SCLK), U12.17 (PA1); also elsewhere on the board
/Sensors Module/CS_SLAVEMCU: U12.14 (OSCOUT_PF1)
/Sensors Module/RTEMP_EN: Q28.2 (G), R77.1, U4.4 (~E0)
/Sensors Module/RTEMP_OUT0: J4.4, R78.2, U12.20 (PA4)
/Sensors Module/RTEMP_OUT1: J4.3, R79.2, U12.1 (PA5)
/Sensors Module/RTEMP_OUT2: J4.2, R81.2, U12.2 (PA6)
/Sensors Module/RTEMP_OUT3: J4.1, R82.2, U12.3 (PA7)
/Sensors Module/RTEMP_R0: U4.1 (A0)
/Sensors Module/RTEMP_R1: U4.2 (A1)
/Sensors Module/RTEMP_R2: U4.3 (A2)
/Sensors Module/SCL: U5.4 (SCK), U7.6 (SCL), U8.12 (SCx), U12.10 (PB6)
/Sensors Module/SDA: U5.3 (SDI), U7.1 (SDA), U8.2 (SDx), U12.11 (PB7)
/Sensors Module/Vmid: C36.1, C40.2, R73.2, R74.1, U6.1 (+)
/Sensors Module/WDET_EN: Q27.2 (G), R72.1, U12.12 (BOOT0_PF4)
/Sensors Module/WDET_OUT: R83.2, U6.5, U12.19 (PA3)
/Sensors Module/WDET_PWM: R75.1, U12.13 (OSCIN_PF0)
GND: C40.1, C41.1, C45.1, C52.1, C53.1, C54.1, R74.2, U4.5 (~E1), U4.8 (GND), U5.1 (GND), U5.7 (GND), U6.4 (V-), U7.2 (GND), U7.7 (PAD), U8.8 (GNDIO), U8.9 (GND), U9.15 (GND), U12.4 (VSS), U12.21 (EP); also elsewhere on the board
unnamed: C41.2, R75.2, R76.1
unnamed: J2.1, U4.15 (~Y0)
unnamed: J2.2, U4.14 (~Y1)
unnamed: J2.3, U4.13 (~Y2)
unnamed: J2.4, U4.12 (~Y3)
unnamed: J2.5, U4.11 (~Y4)
unnamed: J2.6, U4.10 (~Y5)
unnamed: J2.7, U4.9 (~Y6)
unnamed: J2.8, U4.7 (~Y7)
unnamed: J3.1, R76.2
unnamed: J3.2, R80.1
unnamed: C36.2, Q27.1 (D), R73.1
unnamed: Q28.1 (D), R78.1, R79.1, R81.1, R82.1
unnamed: R80.2, R83.1, U6.2 (-)

Parts:
C30, C31: 8p; C_0402_1005Metric
C32, C33: 12.5p; C_0402_1005Metric
C34: 22u; C_0805_2012Metric
C35, C37, C38, C39: 100n; C_0402_1005Metric
C42, C46: C; C_0603_1608Metric
C43, C44: 100nF; C_0603_1608Metric
D31: LED_ABGR
D32: 2.0V; D_SOD-523
D33, D34, D35, D36, D37, D38: ESD5Zxx; D_SOD-523
F1, F2, F3, F4: Polyfuse; Fuse_0603_1608Metric
FB1, FB2, FB3, FB4: 120; L_0603_1608Metric
GD1, GD2, GD3, GD4, GD5, GD6: GDT_2Pin; C_1206_3216Metric
J5, J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1, L2: L_Coupled; L_CommonModeChoke_Coilcraft_1812CAN
LS1: Speaker_Crystal; PinHeader_1x02_P2.54mm_Vertical
Q5, Q6, Q7, Q8, Q9: Q_NPN_BEC; SOT-23
R61, R65, R66: 10k; R_0402_1005Metric
R62, R63, R64: 4.7k; R_0402_1005Metric
R67, R69, R71: 150; R_0603_1608Metric
R68, R70: 1k; R_0603_1608Metric
R84, R85, R86, R87: 10k
R101, R102, R103: 1M; R_0603_1608Metric
U2: CH32V103C8T6; LQFP-48_7x7mm_P0.5mm
U3: XTSD01G; LGA-8_8x6mm_P1.27mm
U10: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U11: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: C34.1, C35.1, C37.1, C38.1, C39.1, R84.1, R85.1, R86.1, R87.1, U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U3.8 (VDD), U10.5 (VIO); also elsewhere on the board
+5V: C42.2, C46.2, D31.1 (A), R68.1, R70.1, U10.3 (VCC), U11.8 (VCC); also elsewhere on the board
/CS_AD: U2.29 (PA8); also elsewhere on the board
/CS_AFE: U2.38 (PA15); also elsewhere on the board
/CS_BLE: U2.37 (PA14)
/MCU Module/CANRX: U2.32 (PA11), U10.4 (RXD)
/MCU Module/CANSTB: U2.34 (PA13), U10.8 (STB)
/MCU Module/CANTX: U2.33 (PA12), U10.1 (TXD)
/MCU Module/CS_SD: U2.28 (PB15), U3.2 (SD3/~CS)
/MCU Module/KEY_WKUP: U2.10 (PA0)
/MCU Module/LED_B: R64.1, U2.18 (PB0)
/MCU Module/LED_G: R63.1, U2.17 (PA7)
/MCU Module/LED_R: R62.1, U2.16 (PA6)
/MCU Module/MAX485_DI: U11.4 (DI)
/MCU Module/MAX485_RO: D32.2 (A)
/MCU Module/MAX485_TR: U11.2 (~RE), U11.3 (DE)
/MCU Module/RESET: U2.7 (NRST)
/MCU Module/RXD1: U2.31 (PA10)
/MCU Module/SCL2: R86.2, U2.21 (PB10)
/MCU Module/SDA2: R87.2, U2.22 (PB11)
/MCU Module/SPK+: R65.1, U2.45 (PB8)
/MCU Module/SPK-: R66.1, U2.46 (PB9)
/MCU Module/TXD1: U2.30 (PA9)
/MISO: U2.40 (PB4), U3.6 (SD0/DO); also elsewhere on the board
/MOSI: U2.41 (PB5), U3.5 (CMD/DI); also elsewhere on the board
/SCL1: R84.2, U2.42 (PB6)
/SCLK: U2.39 (PB3), U3.3 (CLK); also elsewhere on the board
/SDA1: R85.2, U2.43 (PB7)
GND: C30.1, C31.1, C32.1, C33.1, C34.2, C35.2, C37.2, C38.2, C39.2, C42.1, C46.1, D33.2 (A), D35.2 (A), D36.2 (A), D38.2 (A), GD1.2, GD3.2, GD4.2, GD6.2, Q6.2 (E), Q8.2 (E), R61.1, R101.2, R103.2, U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.4 (VSS), U10.2 (GND), U11.5 (GND), Y1.1, Y1.3; also elsewhere on the board
unnamed: C43.1, FB1.2
unnamed: C44.1, FB2.2
unnamed: D31.2 (BK), R71.1
unnamed: D31.3 (GK), R69.1
unnamed: D31.4 (RK), R67.1
unnamed: D32.1 (K), U11.1 (RO)
unnamed: D33.1 (K), D34.1 (K), F1.1, L1.2, R101.1, R102.1
unnamed: D34.2 (A), D35.1 (K), F2.1, L1.3, R102.2, R103.1
unnamed: D36.1 (K), D37.2 (A), F4.1, L2.2
unnamed: D37.1 (K), D38.1 (K), F3.1, L2.3
unnamed: F1.2, FB1.1
unnamed: F2.2, FB2.1
unnamed: F3.2, FB3.1
unnamed: F4.2, FB4.1
unnamed: FB3.2, GD4.1, GD5.1, J5.1
unnamed: FB4.2, GD5.2, GD6.1, J5.2
unnamed: C43.2, GD1.1, GD2.1, J6.1
unnamed: C44.2, GD2.2, GD3.1, J6.2
unnamed: Q5.1 (B), R64.2
unnamed: Q5.3 (C), R67.2
unnamed: Q5.2 (E), Q7.2 (E), Q9.2 (E)
unnamed: Q6.1 (B), R66.2
unnamed: LS1.1, Q6.3 (C), R68.2
unnamed: Q7.1 (B), R63.2
unnamed: Q7.3 (C), R69.2
unnamed: Q8.1 (B), R65.2
unnamed: LS1.2, Q8.3 (C), R70.2
unnamed: Q9.1 (B), R62.2
unnamed: Q9.3 (C), R71.2
unnamed: R61.2, U2.44 (BOOT0)
unnamed: C32.2, U2.3 (PC14), Y2.2
unnamed: C33.2, U2.4 (PC15), Y2.1
unnamed: C30.2, U2.5 (PD0), Y1.2
unnamed: C31.2, U2.6 (PD1), Y1.4
unnamed: L2.4, U10.7 (CANH)
unnamed: L2.1, U10.6 (CANL)
unnamed: L1.1, U11.6 (A)
unnamed: L1.4, U11.7 (B)

Notes on the sheet:
TIM3_CH4
TIM3_CH3
TODO: 添加一个电子墨水屏接口，用于显示电量等信息
TIM3_CH1
TIM4_CH3
TIM4_CH4
TIM3_CH2

Parts:
C47: 100nF; C_0402_1005Metric
C48: 1uF 100V; C_0805_2012Metric
C49, C50, C51: 10uF; C_0805_2012Metric
D39: D; D_SOD-323
D40, D42, D43: D_Zener; D_SOD-123
D41: DSK210; D_SOD-123F
F5: 100mA; Fuse_0603_1608Metric
FB5: 120; L_0805_2012Metric
L3: 47uH; L_1210_3225Metric
R99: 10k; R_0402_1005Metric
R100: 240k; R_0402_1005Metric
RV1: Varistor; R_1206_3216Metric
U13: YX59012; SOT-23-6
U14: SGM2033-3.3; SOT-23-5

Connections:
+3.3V: C51.1, D43.1 (K), U14.5 (OUT); also elsewhere on the board
+5V: C49.1, C50.1, D42.1 (K), L3.2, R100.2, U14.1 (IN), U14.3 (EN); also elsewhere on the board
/Power/DCDC_EN: U13.4 (~SHDN)
BAT+: F5.1; also elsewhere on the board
GND: C48.1, C49.2, C50.2, C51.2, D40.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), R99.1, RV1.2, U13.2 (GND), U14.2 (GND); also elsewhere on the board
unnamed: D39.2 (A), FB5.2
unnamed: C48.2, D39.1 (K), D40.1 (K), U13.5 (VIN)
unnamed: C47.2, D41.1 (K), L3.1, U13.6 (SW)
unnamed: F5.2, FB5.1, RV1.1
unnamed: C47.1, U13.1 (CB)
unnamed: R99.2, R100.1, U13.3 (FB)

Board: 2 copper layers, 100.0 x 90.0 mm, 274 parts (41 on the bottom side), 197 nets.

## Commit log (part)

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2026-04-18 提交遗留内容，文件修改日期为2025年12月30日
2026-04-20 为元器件分配封装，PCB上对元器件大致布局
2026-04-21 添加README.md和LICENSE.txt
2026-04-21 重新分配位号，使电压采样电路的位号连续
2026-04-22 refactor: AFE相关电路移动到子目录
2026-04-22 更新README.md，添加设计目标
2026-04-24 粗略绘制MCU和传感器相关原理图
2026-05-17 添加sym-lib-table文件
2026-05-17 fix: 修复commit `38e8c9e`将元器件移动子原理图到造成的位号混乱
2026-05-17 分配MCU引脚，连接原理图，添加CAN收发器
2026-06-15 添加PB7170(LQFP-64)符号，原符号重命名为PB7170P48(LQFP-48)并应用于原理图，更新到PCB文件
2026-06-16 AFE改为PB7170(LQFP-64)，修改原理图，调整元器件布局
2026-06-19 充放电MOS管改为6个并联
2026-06-20 添加部分布线（电压、电流采样和MOS管控制），划定外框
2026-06-22 分配封装和在PCB上大致布局
2026-06-28 分配封装，添加RS485通信接口，调整布局，传感器连接到独立MCU上
2026-06-28 修改电源电路
